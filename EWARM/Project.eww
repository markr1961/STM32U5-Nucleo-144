<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32U5-nucleo-graphics.ewp</path>
  </project>
  <batchBuild />
</workspace>
